# Keil uVision project RM.uvprojx, settings and files
target RM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARDUINO=111
  c include: ..\USER;..\Libraries;..\ArduinoAPI;..\Core;..\Core\STM32F10x_StdPeriph_Driver\inc;..\Core\CMSIS\CM3\CoreSupport;..\USER\RCX;..\Libraries\NRF;..\USER;..\Core\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\Servo
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: ComBasic.cpp Handle_Ctrl.cpp Handle_LED.cpp Handle_Passback.cpp Handle_System.cpp Handle_Sbus.cpp main.cpp
  group RCX
    ../USER/RCX/: crc.cpp RCX_Channel.cpp RCX_RxPackage.cpp RCX_TxPackage.cpp RCX.h RCX_Config.h RCX_Handshake.h
    ../USER/RCX/Slaver/: RCX_Handshake.cpp
  group Libraries
    ../Libraries/NRF/: NRF_Basic.cpp NRF_FHSS.cpp NRF_TRM.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/Servo/: Servo.cpp
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp HardwareSerial.cpp Stream.cpp WString.cpp WireBase.cpp Wire.cpp WMath.cpp Tone.cpp SPI.cpp
  group Core
    ../Core/: adc.c delay.c exti.c gpio.c pwm.c timer.c
  group StdPeriph_Driver
    ../Core/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../Core/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Core/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c

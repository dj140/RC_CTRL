# Keil uVision project proj.uvprojx, settings and files
target RCX_Mini (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F031G6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARDUINO=111
  c misc: --gnu
  c include: ..\USER;..\Libraries;..\ArduinoAPI;..\Core;..\Core\STM32F0xx_StdPeriph_Driver\inc;..\Core\CMSIS\Device\ST\STM32F0xx\Include;..\Core\CMSIS\Include;..\Libraries\ButtonEvent;..\Libraries\odrive
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ../USER/: main.cpp ComBasic.cpp Handle_LED.cpp Handle_Ctrl.cpp Handle_Passback.cpp Handle_System.cpp Handle_Sbus.cpp
  group RCX
    ../USER/RCX/: RCX_Config.h RCX.h RCX_Channel.cpp RCX_RxPackage.cpp RCX_TxPackage.cpp crc.cpp
    ../USER/RCX/Slaver/: RCX_Handshake.cpp
  group Libraries
    ../Libraries/NRF/: NRF_Basic.cpp NRF_FHSS.cpp NRF_TRM.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/odrive/: ODriveArduino.cpp
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c Print.cpp itoa.c HardwareSerial.cpp Stream.cpp WString.cpp WireBase.cpp Wire.cpp WMath.cpp Tone.cpp SPI.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c
    ../CORE/: delay.c
  group StdPeriph_Driver
    ../Core/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Startup
    ../Core/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group CMSIS
    ../Core/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
software components: CMSIS:CORE 5.2.0

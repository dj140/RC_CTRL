# Keil uVision project X-CTRL.uvprojx, settings and files
target X-CTRL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F412ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: X-CTRL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARDUINO=111,STM32F411xE
  c misc: --gnu
  c include: ..\ArduinoAPI;..\Core;..\Libraries;..\Core\STM32F4xx_StdPeriph_Driver\inc;..\Core\CMSIS\Device\ST\STM32F4xx\Include;..\X-CTRL;..\Libraries\FreeRTOS;..\Libraries\FreeRTOS\Source\include;..\Libraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Libraries\Streaming;..\X-CTRL\Game;..\Libraries\EEPROM;..\Libraries\EEPROM_File;..\X-CTRL\Game\Arduboy
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Basic
    ../X-CTRL/Basic/: main.cpp Initialization.cpp FileGroup.h SysConfig.h XC_Type.h
  group BSP
    ../X-CTRL/BSP/: BSP.h BSP_Audio.cpp BSP_Backlight.cpp BSP_Buttons.cpp BSP_Bluetooth.cpp BSP_DataStorage.cpp BSP_IMU.cpp BSP_I2C_Scan.cpp BSP_Joystick.cpp BSP_MotorERM.cpp BSP_MotorLRA.cpp BSP_Power.cpp BSP_Switch.cpp
  group Model
    ../X-CTRL/Model/: XC_Model.cpp
  group Communication
    ../X-CTRL/Communication/: ComPrivate.h ComBasic.cpp ComPassback.cpp ComTest.cpp ComDevChannel.cpp
  group Passback
    ../X-CTRL/Communication/Passback/: XBox360Sim.cpp
  group RCX
    ../X-CTRL/Communication/RCX/: RCX.h RCX_Config.h RCX_Channel.cpp RCX_RxPackage.cpp RCX_TxPackage.cpp crc.cpp
    ../X-CTRL/Communication/RCX/Master/: RCX_Handshake.cpp
  group GUI
    ../X-CTRL/GUI/: DisplayPrivate.h DisplayBasic.cpp DisplayBar.cpp DisplayAppWin.cpp DisplayError.cpp lv_port_disp.cpp lv_ext_func.cpp lv_settings.cpp
    ../Libraries/: lv_conf.h
  group GUI/Page
    ../X-CTRL/GUI/: DisplayPage.cpp
    ../X-CTRL/GUI/Page/: Page_EXAMPLE.cpp Page_Home.cpp Page_CtrlPage.cpp Page_HandshakeAuto.cpp Page_Handshake.cpp Page_ChannelCfg.cpp Page_ChannelRevCfg.cpp Page_JoystickCfg.cpp Page_JoystickCurveCfg.cpp Page_ModelCfg.cpp Page_RadioCfg.cpp Page_Scanner.cpp Page_GyroscopeCfg.cpp Page_BluetoothCfg.cpp Page_MiscCfg.cpp
  group GUI/Widgets
    ../X-CTRL/GUI/Widgets/: lv_joystick.c
  group GUI/IMG
    ../X-CTRL/GUI/IMG/: IMG_JsFrame.c IMG_Bluetooth.c IMG_JsStick.c IMG_Sign0.c IMG_Sign1.c IMG_Sign2.c IMG_Sign3.c IMG_Switch.c IMG_Battery.c IMG_Download.c IMG_Upload.c IMG_NoUpDownload.c IMG_Background.c IMG_Channel.c IMG_Model.c IMG_RemoteCtrl.c IMG_Settings.c IMG_Scan.c IMG_RadioCfg.c IMG_Gyroscope.c IMG_Disnet.c IMG_Bluetooth2.c IMG_Game1.c IMG_Stopwatch2.c IMG_Joystick.c IMG_Background5.c IMG_Car.c
  group GUI/Font
    ../X-CTRL/GUI/Font/: EuroStar_26.c EuroStar_60.c HandGotn_14.c HandGotn_20.c HandGotn_26.c Morganite_36.c Morganite_100.c
  group Game
    ../X-CTRL/Game/: GameDisp.cpp GameDisp.h GameManager.cpp GamePrivate.h Page_Game.cpp
  group Game/Arduboy
    ../X-CTRL/Game/Arduboy/: Arduboy.cpp
    ../X-CTRL/Game/Arduboy/core/: core.cpp
    ../X-CTRL/Game/Arduboy/audio/: audio.cpp
  group Game/Arduboy2
    ../X-CTRL/Game/Arduboy2/: Arduboy2.cpp Arduboy2Audio.cpp Arduboy2Beep.cpp Arduboy2Core.cpp Sprites.cpp SpritesB.cpp
  group Game/chribocchi
    ../X-CTRL/Game/chribocchi/: chribocchi.cpp common.h game.cpp logo.cpp MyArduboy.cpp MyArduboy.h title.cpp
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/Adafruit_ST7789/: Adafruit_ST7789.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/SwitchEvent/: SwitchEvent.cpp
    ../Libraries/EncoderEvent/: EncoderEvent.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/PageManager/: PageManager.cpp
    ../Libraries/NRF/: NRF_Basic.cpp NRF_TRM.cpp NRF_FHSS.cpp
    ../Libraries/MusicPlayer/: MusicPlayer.cpp
    ../Libraries/extEEPROM/: extEEPROM.cpp
    ../Libraries/IP5108/: IP5108.cpp
    ../Libraries/Bluetooth_HC05/: Bluetooth_HC05.cpp
    ../Libraries/Filters/: Filters.cpp
    ../Libraries/JoystickMap/: JoystickMap.cpp
    ../Libraries/EEPROM/: EEPROM.cpp
    ../Libraries/EEPROM_File/: EEPROM_File.cpp
  group LittlevGL
    ../Libraries/lvgl/src/lv_core/: lv_debug.c lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Libraries/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../Libraries/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c
    ../Libraries/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Libraries/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../Libraries/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_cpicker.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../Libraries/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp WString.cpp Stream.cpp WMath.cpp HardwareSerial.cpp WireBase.cpp Wire.cpp SPI.cpp Tone.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c
    ../CORE/: delay.c
  group cm_backtrace
    ../Libraries/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../Libraries/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group STM32F4xx_StdPeriph_Driver
    ../Core/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Startup
    ../Core/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group CMSIS
    ../Core/: system_stm32f4xx.c
  group README
    ../: README.md
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0
